vinput0 a[3] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 19300000PS LOW 19301000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 26500000PS LOW 26501000PS HIGH
+ 30100000PS HIGH 30101000PS LOW
+  )

vinput1 a[2] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 17700000PS LOW 17701000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 20900000PS LOW 20901000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 24900000PS LOW 24901000PS HIGH
+ 26500000PS HIGH 26501000PS LOW
+ 28100000PS LOW 28101000PS HIGH
+ 30100000PS HIGH 30101000PS LOW
+  )

vinput2 a[1] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 16900000PS LOW 16901000PS HIGH
+ 17700000PS HIGH 17701000PS LOW
+ 18500000PS LOW 18501000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 20100000PS LOW 20101000PS HIGH
+ 20900000PS HIGH 20901000PS LOW
+ 21700000PS LOW 21701000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 24100000PS LOW 24101000PS HIGH
+ 24900000PS HIGH 24901000PS LOW
+ 25700000PS LOW 25701000PS HIGH
+ 26500000PS HIGH 26501000PS LOW
+ 27300000PS LOW 27301000PS HIGH
+ 28100000PS HIGH 28101000PS LOW
+ 28900000PS LOW 28901000PS HIGH
+ 30100000PS HIGH 30101000PS LOW
+  )

vinput3 a[0] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 16500000PS LOW 16501000PS HIGH
+ 16900000PS HIGH 16901000PS LOW
+ 17300000PS LOW 17301000PS HIGH
+ 17700000PS HIGH 17701000PS LOW
+ 18100000PS LOW 18101000PS HIGH
+ 18500000PS HIGH 18501000PS LOW
+ 18900000PS LOW 18901000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 19700000PS LOW 19701000PS HIGH
+ 20100000PS HIGH 20101000PS LOW
+ 20500000PS LOW 20501000PS HIGH
+ 20900000PS HIGH 20901000PS LOW
+ 21300000PS LOW 21301000PS HIGH
+ 21700000PS HIGH 21701000PS LOW
+ 22100000PS LOW 22101000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 23700000PS LOW 23701000PS HIGH
+ 24100000PS HIGH 24101000PS LOW
+ 24500000PS LOW 24501000PS HIGH
+ 24900000PS HIGH 24901000PS LOW
+ 25300000PS LOW 25301000PS HIGH
+ 25700000PS HIGH 25701000PS LOW
+ 26100000PS LOW 26101000PS HIGH
+ 26500000PS HIGH 26501000PS LOW
+ 26900000PS LOW 26901000PS HIGH
+ 27300000PS HIGH 27301000PS LOW
+ 27700000PS LOW 27701000PS HIGH
+ 28100000PS HIGH 28101000PS LOW
+ 28500000PS LOW 28501000PS HIGH
+ 28900000PS HIGH 28901000PS LOW
+ 29300000PS LOW 29301000PS HIGH
+ 30100000PS HIGH 30101000PS LOW
+  )

vinput4 b[3] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 4500000PS LOW 4501000PS HIGH
+ 4900000PS HIGH 4901000PS LOW
+ 12500000PS LOW 12501000PS HIGH
+ 12900000PS HIGH 12901000PS LOW
+ 19300000PS LOW 19301000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 36900000PS LOW 36901000PS HIGH
+ 43300000PS HIGH 43301000PS LOW
+  )

vinput5 b[2] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 2900000PS LOW 2901000PS HIGH
+ 4500000PS HIGH 4501000PS LOW
+ 6500000PS LOW 6501000PS HIGH
+ 9300000PS HIGH 9301000PS LOW
+ 10900000PS LOW 10901000PS HIGH
+ 12500000PS HIGH 12501000PS LOW
+ 14500000PS LOW 14501000PS HIGH
+ 16100000PS HIGH 16101000PS LOW
+ 17700000PS LOW 17701000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 20900000PS LOW 20901000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 33700000PS LOW 33701000PS HIGH
+ 36900000PS HIGH 36901000PS LOW
+ 40100000PS LOW 40101000PS HIGH
+ 43300000PS HIGH 43301000PS LOW
+  )

vinput6 b[1] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 2100000PS LOW 2101000PS HIGH
+ 2900000PS HIGH 2901000PS LOW
+ 3700000PS LOW 3701000PS HIGH
+ 4500000PS HIGH 4501000PS LOW
+ 5700000PS LOW 5701000PS HIGH
+ 6500000PS HIGH 6501000PS LOW
+ 7300000PS LOW 7301000PS HIGH
+ 9300000PS HIGH 9301000PS LOW
+ 10100000PS LOW 10101000PS HIGH
+ 10900000PS HIGH 10901000PS LOW
+ 11700000PS LOW 11701000PS HIGH
+ 12500000PS HIGH 12501000PS LOW
+ 13700000PS LOW 13701000PS HIGH
+ 14500000PS HIGH 14501000PS LOW
+ 15300000PS LOW 15301000PS HIGH
+ 16100000PS HIGH 16101000PS LOW
+ 16900000PS LOW 16901000PS HIGH
+ 17700000PS HIGH 17701000PS LOW
+ 18500000PS LOW 18501000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 20100000PS LOW 20101000PS HIGH
+ 20900000PS HIGH 20901000PS LOW
+ 21700000PS LOW 21701000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 32100000PS LOW 32101000PS HIGH
+ 33700000PS HIGH 33701000PS LOW
+ 35300000PS LOW 35301000PS HIGH
+ 36900000PS HIGH 36901000PS LOW
+ 38500000PS LOW 38501000PS HIGH
+ 40100000PS HIGH 40101000PS LOW
+ 41700000PS LOW 41701000PS HIGH
+ 43300000PS HIGH 43301000PS LOW
+  )

vinput7 b[0] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 1700000PS LOW 1701000PS HIGH
+ 2100000PS HIGH 2101000PS LOW
+ 2500000PS LOW 2501000PS HIGH
+ 2900000PS HIGH 2901000PS LOW
+ 3300000PS LOW 3301000PS HIGH
+ 3700000PS HIGH 3701000PS LOW
+ 4100000PS LOW 4101000PS HIGH
+ 4500000PS HIGH 4501000PS LOW
+ 5300000PS LOW 5301000PS HIGH
+ 5700000PS HIGH 5701000PS LOW
+ 6100000PS LOW 6101000PS HIGH
+ 6500000PS HIGH 6501000PS LOW
+ 6900000PS LOW 6901000PS HIGH
+ 7300000PS HIGH 7301000PS LOW
+ 7700000PS LOW 7701000PS HIGH
+ 9300000PS HIGH 9301000PS LOW
+ 9700000PS LOW 9701000PS HIGH
+ 10100000PS HIGH 10101000PS LOW
+ 10500000PS LOW 10501000PS HIGH
+ 10900000PS HIGH 10901000PS LOW
+ 11300000PS LOW 11301000PS HIGH
+ 11700000PS HIGH 11701000PS LOW
+ 12100000PS LOW 12101000PS HIGH
+ 12500000PS HIGH 12501000PS LOW
+ 13300000PS LOW 13301000PS HIGH
+ 13700000PS HIGH 13701000PS LOW
+ 14100000PS LOW 14101000PS HIGH
+ 14500000PS HIGH 14501000PS LOW
+ 14900000PS LOW 14901000PS HIGH
+ 15300000PS HIGH 15301000PS LOW
+ 15700000PS LOW 15701000PS HIGH
+ 16100000PS HIGH 16101000PS LOW
+ 16500000PS LOW 16501000PS HIGH
+ 16900000PS HIGH 16901000PS LOW
+ 17300000PS LOW 17301000PS HIGH
+ 17700000PS HIGH 17701000PS LOW
+ 18100000PS LOW 18101000PS HIGH
+ 18500000PS HIGH 18501000PS LOW
+ 18900000PS LOW 18901000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 19700000PS LOW 19701000PS HIGH
+ 20100000PS HIGH 20101000PS LOW
+ 20500000PS LOW 20501000PS HIGH
+ 20900000PS HIGH 20901000PS LOW
+ 21300000PS LOW 21301000PS HIGH
+ 21700000PS HIGH 21701000PS LOW
+ 22100000PS LOW 22101000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 31300000PS LOW 31301000PS HIGH
+ 32100000PS HIGH 32101000PS LOW
+ 32900000PS LOW 32901000PS HIGH
+ 33700000PS HIGH 33701000PS LOW
+ 34500000PS LOW 34501000PS HIGH
+ 35300000PS HIGH 35301000PS LOW
+ 36100000PS LOW 36101000PS HIGH
+ 36900000PS HIGH 36901000PS LOW
+ 37700000PS LOW 37701000PS HIGH
+ 38500000PS HIGH 38501000PS LOW
+ 39300000PS LOW 39301000PS HIGH
+ 40100000PS HIGH 40101000PS LOW
+ 40900000PS LOW 40901000PS HIGH
+ 41700000PS HIGH 41701000PS LOW
+ 42500000PS LOW 42501000PS HIGH
+ 43300000PS HIGH 43301000PS LOW
+  )

vinput8 d[3] 0 PWL (
+ 0PS HIGH 1000PS HIGH
+ 500000PS HIGH 501000PS LOW
+ 900000PS LOW 901000PS HIGH
+ 8500000PS HIGH 8501000PS LOW
+ 8900000PS LOW 8901000PS HIGH
+ 16100000PS HIGH 16101000PS LOW
+ 19300000PS LOW 19301000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 46500000PS LOW 46501000PS HIGH
+ 49700000PS HIGH 49701000PS LOW
+ 52900000PS LOW 52901000PS HIGH
+ 56100000PS HIGH 56101000PS LOW
+ 59300000PS LOW 59301000PS HIGH
+ 62500000PS HIGH 62501000PS LOW
+ 65700000PS LOW 65701000PS HIGH
+ 68900000PS HIGH 68901000PS LOW
+ 72100000PS LOW 72101000PS HIGH
+ 75300000PS HIGH 75301000PS LOW
+ 78500000PS LOW 78501000PS HIGH
+ 81700000PS HIGH 81701000PS LOW
+ 84900000PS LOW 84901000PS HIGH
+ 88100000PS HIGH 88101000PS LOW
+ 92500000PS LOW 92501000PS HIGH
+ 95700000PS HIGH 95701000PS LOW
+ 97300000PS LOW 97301000PS HIGH
+ 100500000PS HIGH 100501000PS LOW
+ 102100000PS LOW 102101000PS HIGH
+ 105300000PS HIGH 105301000PS LOW
+  )

vinput9 d[2] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 500000PS LOW 501000PS HIGH
+ 900000PS HIGH 901000PS LOW
+ 8500000PS LOW 8501000PS HIGH
+ 8900000PS HIGH 8901000PS LOW
+ 17700000PS LOW 17701000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 20900000PS LOW 20901000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 44900000PS LOW 44901000PS HIGH
+ 46500000PS HIGH 46501000PS LOW
+ 48100000PS LOW 48101000PS HIGH
+ 49700000PS HIGH 49701000PS LOW
+ 51300000PS LOW 51301000PS HIGH
+ 52900000PS HIGH 52901000PS LOW
+ 54500000PS LOW 54501000PS HIGH
+ 56100000PS HIGH 56101000PS LOW
+ 57700000PS LOW 57701000PS HIGH
+ 59300000PS HIGH 59301000PS LOW
+ 60900000PS LOW 60901000PS HIGH
+ 62500000PS HIGH 62501000PS LOW
+ 64100000PS LOW 64101000PS HIGH
+ 65700000PS HIGH 65701000PS LOW
+ 67300000PS LOW 67301000PS HIGH
+ 68900000PS HIGH 68901000PS LOW
+ 70500000PS LOW 70501000PS HIGH
+ 72100000PS HIGH 72101000PS LOW
+ 73700000PS LOW 73701000PS HIGH
+ 75300000PS HIGH 75301000PS LOW
+ 76900000PS LOW 76901000PS HIGH
+ 78500000PS HIGH 78501000PS LOW
+ 80100000PS LOW 80101000PS HIGH
+ 81700000PS HIGH 81701000PS LOW
+ 83300000PS LOW 83301000PS HIGH
+ 84900000PS HIGH 84901000PS LOW
+ 86500000PS LOW 86501000PS HIGH
+ 89300000PS HIGH 89301000PS LOW
+ 90900000PS LOW 90901000PS HIGH
+ 92500000PS HIGH 92501000PS LOW
+ 94100000PS LOW 94101000PS HIGH
+ 97300000PS HIGH 97301000PS LOW
+ 98900000PS LOW 98901000PS HIGH
+ 100500000PS HIGH 100501000PS LOW
+ 103700000PS LOW 103701000PS HIGH
+ 105300000PS HIGH 105301000PS LOW
+ 106900000PS LOW 106901000PS HIGH
+  )

vinput10 d[1] 0 PWL (
+ 0PS HIGH 1000PS HIGH
+ 500000PS HIGH 501000PS LOW
+ 900000PS LOW 901000PS HIGH
+ 8500000PS HIGH 8501000PS LOW
+ 8900000PS LOW 8901000PS HIGH
+ 16100000PS HIGH 16101000PS LOW
+ 16900000PS LOW 16901000PS HIGH
+ 17700000PS HIGH 17701000PS LOW
+ 18500000PS LOW 18501000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 20100000PS LOW 20101000PS HIGH
+ 20900000PS HIGH 20901000PS LOW
+ 21700000PS LOW 21701000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 44100000PS LOW 44101000PS HIGH
+ 44900000PS HIGH 44901000PS LOW
+ 45700000PS LOW 45701000PS HIGH
+ 46500000PS HIGH 46501000PS LOW
+ 47300000PS LOW 47301000PS HIGH
+ 48100000PS HIGH 48101000PS LOW
+ 48900000PS LOW 48901000PS HIGH
+ 49700000PS HIGH 49701000PS LOW
+ 50500000PS LOW 50501000PS HIGH
+ 51300000PS HIGH 51301000PS LOW
+ 52100000PS LOW 52101000PS HIGH
+ 52900000PS HIGH 52901000PS LOW
+ 53700000PS LOW 53701000PS HIGH
+ 54500000PS HIGH 54501000PS LOW
+ 55300000PS LOW 55301000PS HIGH
+ 56100000PS HIGH 56101000PS LOW
+ 56900000PS LOW 56901000PS HIGH
+ 57700000PS HIGH 57701000PS LOW
+ 58500000PS LOW 58501000PS HIGH
+ 59300000PS HIGH 59301000PS LOW
+ 60100000PS LOW 60101000PS HIGH
+ 60900000PS HIGH 60901000PS LOW
+ 61700000PS LOW 61701000PS HIGH
+ 62500000PS HIGH 62501000PS LOW
+ 63300000PS LOW 63301000PS HIGH
+ 64100000PS HIGH 64101000PS LOW
+ 64900000PS LOW 64901000PS HIGH
+ 65700000PS HIGH 65701000PS LOW
+ 66500000PS LOW 66501000PS HIGH
+ 67300000PS HIGH 67301000PS LOW
+ 68100000PS LOW 68101000PS HIGH
+ 68900000PS HIGH 68901000PS LOW
+ 69700000PS LOW 69701000PS HIGH
+ 70500000PS HIGH 70501000PS LOW
+ 71300000PS LOW 71301000PS HIGH
+ 72100000PS HIGH 72101000PS LOW
+ 72900000PS LOW 72901000PS HIGH
+ 73700000PS HIGH 73701000PS LOW
+ 74500000PS LOW 74501000PS HIGH
+ 75300000PS HIGH 75301000PS LOW
+ 76100000PS LOW 76101000PS HIGH
+ 76900000PS HIGH 76901000PS LOW
+ 77700000PS LOW 77701000PS HIGH
+ 78500000PS HIGH 78501000PS LOW
+ 79300000PS LOW 79301000PS HIGH
+ 80100000PS HIGH 80101000PS LOW
+ 80900000PS LOW 80901000PS HIGH
+ 81700000PS HIGH 81701000PS LOW
+ 82500000PS LOW 82501000PS HIGH
+ 83300000PS HIGH 83301000PS LOW
+ 84100000PS LOW 84101000PS HIGH
+ 84900000PS HIGH 84901000PS LOW
+ 85700000PS LOW 85701000PS HIGH
+ 86500000PS HIGH 86501000PS LOW
+ 87300000PS LOW 87301000PS HIGH
+ 88100000PS HIGH 88101000PS LOW
+ 90100000PS LOW 90101000PS HIGH
+ 90900000PS HIGH 90901000PS LOW
+ 91700000PS LOW 91701000PS HIGH
+ 92500000PS HIGH 92501000PS LOW
+ 93300000PS LOW 93301000PS HIGH
+ 94100000PS HIGH 94101000PS LOW
+ 94900000PS LOW 94901000PS HIGH
+ 95700000PS HIGH 95701000PS LOW
+ 96500000PS LOW 96501000PS HIGH
+ 97300000PS HIGH 97301000PS LOW
+ 98100000PS LOW 98101000PS HIGH
+ 98900000PS HIGH 98901000PS LOW
+ 99700000PS LOW 99701000PS HIGH
+ 100500000PS HIGH 100501000PS LOW
+ 101300000PS LOW 101301000PS HIGH
+ 102100000PS HIGH 102101000PS LOW
+ 102900000PS LOW 102901000PS HIGH
+ 103700000PS HIGH 103701000PS LOW
+ 104500000PS LOW 104501000PS HIGH
+ 105300000PS HIGH 105301000PS LOW
+ 106100000PS LOW 106101000PS HIGH
+ 106900000PS HIGH 106901000PS LOW
+ 107700000PS LOW 107701000PS HIGH
+  )

vinput11 d[0] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 500000PS LOW 501000PS HIGH
+ 900000PS HIGH 901000PS LOW
+ 8500000PS LOW 8501000PS HIGH
+ 8900000PS HIGH 8901000PS LOW
+ 16500000PS LOW 16501000PS HIGH
+ 16900000PS HIGH 16901000PS LOW
+ 17300000PS LOW 17301000PS HIGH
+ 17700000PS HIGH 17701000PS LOW
+ 18100000PS LOW 18101000PS HIGH
+ 18500000PS HIGH 18501000PS LOW
+ 18900000PS LOW 18901000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 19700000PS LOW 19701000PS HIGH
+ 20100000PS HIGH 20101000PS LOW
+ 20500000PS LOW 20501000PS HIGH
+ 20900000PS HIGH 20901000PS LOW
+ 21300000PS LOW 21301000PS HIGH
+ 21700000PS HIGH 21701000PS LOW
+ 22100000PS LOW 22101000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 43700000PS LOW 43701000PS HIGH
+ 44100000PS HIGH 44101000PS LOW
+ 44500000PS LOW 44501000PS HIGH
+ 44900000PS HIGH 44901000PS LOW
+ 45300000PS LOW 45301000PS HIGH
+ 45700000PS HIGH 45701000PS LOW
+ 46100000PS LOW 46101000PS HIGH
+ 46500000PS HIGH 46501000PS LOW
+ 46900000PS LOW 46901000PS HIGH
+ 47300000PS HIGH 47301000PS LOW
+ 47700000PS LOW 47701000PS HIGH
+ 48100000PS HIGH 48101000PS LOW
+ 48500000PS LOW 48501000PS HIGH
+ 48900000PS HIGH 48901000PS LOW
+ 49300000PS LOW 49301000PS HIGH
+ 49700000PS HIGH 49701000PS LOW
+ 50100000PS LOW 50101000PS HIGH
+ 50500000PS HIGH 50501000PS LOW
+ 50900000PS LOW 50901000PS HIGH
+ 51300000PS HIGH 51301000PS LOW
+ 51700000PS LOW 51701000PS HIGH
+ 52100000PS HIGH 52101000PS LOW
+ 52500000PS LOW 52501000PS HIGH
+ 52900000PS HIGH 52901000PS LOW
+ 53300000PS LOW 53301000PS HIGH
+ 53700000PS HIGH 53701000PS LOW
+ 54100000PS LOW 54101000PS HIGH
+ 54500000PS HIGH 54501000PS LOW
+ 54900000PS LOW 54901000PS HIGH
+ 55300000PS HIGH 55301000PS LOW
+ 55700000PS LOW 55701000PS HIGH
+ 56100000PS HIGH 56101000PS LOW
+ 56500000PS LOW 56501000PS HIGH
+ 56900000PS HIGH 56901000PS LOW
+ 57300000PS LOW 57301000PS HIGH
+ 57700000PS HIGH 57701000PS LOW
+ 58100000PS LOW 58101000PS HIGH
+ 58500000PS HIGH 58501000PS LOW
+ 58900000PS LOW 58901000PS HIGH
+ 59300000PS HIGH 59301000PS LOW
+ 59700000PS LOW 59701000PS HIGH
+ 60100000PS HIGH 60101000PS LOW
+ 60500000PS LOW 60501000PS HIGH
+ 60900000PS HIGH 60901000PS LOW
+ 61300000PS LOW 61301000PS HIGH
+ 61700000PS HIGH 61701000PS LOW
+ 62100000PS LOW 62101000PS HIGH
+ 62500000PS HIGH 62501000PS LOW
+ 62900000PS LOW 62901000PS HIGH
+ 63300000PS HIGH 63301000PS LOW
+ 63700000PS LOW 63701000PS HIGH
+ 64100000PS HIGH 64101000PS LOW
+ 64500000PS LOW 64501000PS HIGH
+ 64900000PS HIGH 64901000PS LOW
+ 65300000PS LOW 65301000PS HIGH
+ 65700000PS HIGH 65701000PS LOW
+ 66100000PS LOW 66101000PS HIGH
+ 66500000PS HIGH 66501000PS LOW
+ 66900000PS LOW 66901000PS HIGH
+ 67300000PS HIGH 67301000PS LOW
+ 67700000PS LOW 67701000PS HIGH
+ 68100000PS HIGH 68101000PS LOW
+ 68500000PS LOW 68501000PS HIGH
+ 68900000PS HIGH 68901000PS LOW
+ 69300000PS LOW 69301000PS HIGH
+ 69700000PS HIGH 69701000PS LOW
+ 70100000PS LOW 70101000PS HIGH
+ 70500000PS HIGH 70501000PS LOW
+ 70900000PS LOW 70901000PS HIGH
+ 71300000PS HIGH 71301000PS LOW
+ 71700000PS LOW 71701000PS HIGH
+ 72100000PS HIGH 72101000PS LOW
+ 72500000PS LOW 72501000PS HIGH
+ 72900000PS HIGH 72901000PS LOW
+ 73300000PS LOW 73301000PS HIGH
+ 73700000PS HIGH 73701000PS LOW
+ 74100000PS LOW 74101000PS HIGH
+ 74500000PS HIGH 74501000PS LOW
+ 74900000PS LOW 74901000PS HIGH
+ 75300000PS HIGH 75301000PS LOW
+ 75700000PS LOW 75701000PS HIGH
+ 76100000PS HIGH 76101000PS LOW
+ 76500000PS LOW 76501000PS HIGH
+ 76900000PS HIGH 76901000PS LOW
+ 77300000PS LOW 77301000PS HIGH
+ 77700000PS HIGH 77701000PS LOW
+ 78100000PS LOW 78101000PS HIGH
+ 78500000PS HIGH 78501000PS LOW
+ 78900000PS LOW 78901000PS HIGH
+ 79300000PS HIGH 79301000PS LOW
+ 79700000PS LOW 79701000PS HIGH
+ 80100000PS HIGH 80101000PS LOW
+ 80500000PS LOW 80501000PS HIGH
+ 80900000PS HIGH 80901000PS LOW
+ 81300000PS LOW 81301000PS HIGH
+ 81700000PS HIGH 81701000PS LOW
+ 82100000PS LOW 82101000PS HIGH
+ 82500000PS HIGH 82501000PS LOW
+ 82900000PS LOW 82901000PS HIGH
+ 83300000PS HIGH 83301000PS LOW
+ 83700000PS LOW 83701000PS HIGH
+ 84100000PS HIGH 84101000PS LOW
+ 84500000PS LOW 84501000PS HIGH
+ 84900000PS HIGH 84901000PS LOW
+ 85300000PS LOW 85301000PS HIGH
+ 85700000PS HIGH 85701000PS LOW
+ 86100000PS LOW 86101000PS HIGH
+ 86500000PS HIGH 86501000PS LOW
+ 86900000PS LOW 86901000PS HIGH
+ 87300000PS HIGH 87301000PS LOW
+ 87700000PS LOW 87701000PS HIGH
+ 89300000PS HIGH 89301000PS LOW
+ 89700000PS LOW 89701000PS HIGH
+ 90100000PS HIGH 90101000PS LOW
+ 90500000PS LOW 90501000PS HIGH
+ 90900000PS HIGH 90901000PS LOW
+ 91300000PS LOW 91301000PS HIGH
+ 91700000PS HIGH 91701000PS LOW
+ 92100000PS LOW 92101000PS HIGH
+ 92500000PS HIGH 92501000PS LOW
+ 92900000PS LOW 92901000PS HIGH
+ 93300000PS HIGH 93301000PS LOW
+ 93700000PS LOW 93701000PS HIGH
+ 94100000PS HIGH 94101000PS LOW
+ 94500000PS LOW 94501000PS HIGH
+ 94900000PS HIGH 94901000PS LOW
+ 95300000PS LOW 95301000PS HIGH
+ 95700000PS HIGH 95701000PS LOW
+ 96100000PS LOW 96101000PS HIGH
+ 96500000PS HIGH 96501000PS LOW
+ 96900000PS LOW 96901000PS HIGH
+ 97300000PS HIGH 97301000PS LOW
+ 97700000PS LOW 97701000PS HIGH
+ 98100000PS HIGH 98101000PS LOW
+ 98500000PS LOW 98501000PS HIGH
+ 98900000PS HIGH 98901000PS LOW
+ 99300000PS LOW 99301000PS HIGH
+ 99700000PS HIGH 99701000PS LOW
+ 100100000PS LOW 100101000PS HIGH
+ 100500000PS HIGH 100501000PS LOW
+ 100900000PS LOW 100901000PS HIGH
+ 101300000PS HIGH 101301000PS LOW
+ 101700000PS LOW 101701000PS HIGH
+ 102100000PS HIGH 102101000PS LOW
+ 102500000PS LOW 102501000PS HIGH
+ 102900000PS HIGH 102901000PS LOW
+ 103300000PS LOW 103301000PS HIGH
+ 103700000PS HIGH 103701000PS LOW
+ 104100000PS LOW 104101000PS HIGH
+ 104500000PS HIGH 104501000PS LOW
+ 104900000PS LOW 104901000PS HIGH
+ 105300000PS HIGH 105301000PS LOW
+ 105700000PS LOW 105701000PS HIGH
+ 106100000PS HIGH 106101000PS LOW
+ 106500000PS LOW 106501000PS HIGH
+ 106900000PS HIGH 106901000PS LOW
+ 107300000PS LOW 107301000PS HIGH
+ 107700000PS HIGH 107701000PS LOW
+ 108100000PS LOW 108101000PS HIGH
+  )

vinput12 i[8] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 1300000PS LOW 1301000PS HIGH
+ 4900000PS HIGH 4901000PS LOW
+ 9300000PS LOW 9301000PS HIGH
+ 12900000PS HIGH 12901000PS LOW
+  )

vinput13 i[7] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 9300000PS LOW 9301000PS HIGH
+ 12900000PS HIGH 12901000PS LOW
+ 16100000PS LOW 16101000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+  )

vinput14 i[6] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 4900000PS LOW 4901000PS HIGH
+ 8100000PS HIGH 8101000PS LOW
+ 12900000PS LOW 12901000PS HIGH
+ 88100000PS HIGH 88101000PS LOW
+ 89300000PS LOW 89301000PS HIGH
+  )

vinput15 i[5] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 1300000PS LOW 1301000PS HIGH
+ 8100000PS HIGH 8101000PS LOW
+ 9300000PS LOW 9301000PS HIGH
+ 16100000PS HIGH 16101000PS LOW
+ 68900000PS LOW 68901000PS HIGH
+ 88100000PS HIGH 88101000PS LOW
+  )

vinput16 i[4] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 900000PS LOW 901000PS HIGH
+ 8100000PS HIGH 8101000PS LOW
+ 8900000PS LOW 8901000PS HIGH
+ 43300000PS HIGH 43301000PS LOW
+ 56100000PS LOW 56101000PS HIGH
+ 88100000PS HIGH 88101000PS LOW
+ 102100000PS LOW 102101000PS HIGH
+  )

vinput17 i[3] 0 PWL (
+ 0PS LOW 1000PS LOW
+ 900000PS LOW 901000PS HIGH
+ 1300000PS HIGH 1301000PS LOW
+ 8900000PS LOW 8901000PS HIGH
+ 9300000PS HIGH 9301000PS LOW
+ 16100000PS LOW 16101000PS HIGH
+ 43300000PS HIGH 43301000PS LOW
+ 49700000PS LOW 49701000PS HIGH
+ 56100000PS HIGH 56101000PS LOW
+ 81700000PS LOW 81701000PS HIGH
+ 88100000PS HIGH 88101000PS LOW
+ 95700000PS LOW 95701000PS HIGH
+ 102100000PS HIGH 102101000PS LOW
+  )

vinput18 i[2] 0 PWL (
+ 0PS HIGH 1000PS HIGH
+ 900000PS HIGH 901000PS LOW
+ 8100000PS LOW 8101000PS HIGH
+ 8900000PS HIGH 8901000PS LOW
+ 16100000PS LOW 16101000PS HIGH
+ 30500000PS HIGH 30501000PS LOW
+ 43300000PS LOW 43301000PS HIGH
+  )

vinput19 i[1] 0 PWL (
+ 0PS HIGH 1000PS HIGH
+ 23300000PS HIGH 23301000PS LOW
+ 30100000PS LOW 30101000PS HIGH
+  )

vinput20 i[0] 0 PWL (
+ 0PS HIGH 1000PS HIGH
+ 900000PS HIGH 901000PS LOW
+ 4900000PS LOW 4901000PS HIGH
+ 8900000PS HIGH 8901000PS LOW
+ 12900000PS LOW 12901000PS HIGH
+ 23300000PS HIGH 23301000PS LOW
+ 30100000PS LOW 30101000PS HIGH
+ 89300000PS HIGH 89301000PS LOW
+  )

vinput21 fonc 0 PWL (
+ 0PS HIGH 1000PS HIGH
+  )

vinput22 test 0 PWL (
+ 0PS LOW 1000PS LOW
+  )

vinput23 scin 0 PWL (
+ 0PS LOW 1000PS LOW
+  )

vinput24 noe 0 PWL (
+ 0PS LOW 1000PS LOW
+  )

vinput25 ck 0 PWL (
+ 0PS LOW 1000PS LOW
+ 300000PS LOW 301000PS HIGH
+ 500000PS HIGH 501000PS LOW
+ 700000PS LOW 701000PS HIGH
+ 900000PS HIGH 901000PS LOW
+ 1100000PS LOW 1101000PS HIGH
+ 1300000PS HIGH 1301000PS LOW
+ 1500000PS LOW 1501000PS HIGH
+ 1700000PS HIGH 1701000PS LOW
+ 1900000PS LOW 1901000PS HIGH
+ 2100000PS HIGH 2101000PS LOW
+ 2300000PS LOW 2301000PS HIGH
+ 2500000PS HIGH 2501000PS LOW
+ 2700000PS LOW 2701000PS HIGH
+ 2900000PS HIGH 2901000PS LOW
+ 3100000PS LOW 3101000PS HIGH
+ 3300000PS HIGH 3301000PS LOW
+ 3500000PS LOW 3501000PS HIGH
+ 3700000PS HIGH 3701000PS LOW
+ 3900000PS LOW 3901000PS HIGH
+ 4100000PS HIGH 4101000PS LOW
+ 4300000PS LOW 4301000PS HIGH
+ 4500000PS HIGH 4501000PS LOW
+ 4700000PS LOW 4701000PS HIGH
+ 4900000PS HIGH 4901000PS LOW
+ 5100000PS LOW 5101000PS HIGH
+ 5300000PS HIGH 5301000PS LOW
+ 5500000PS LOW 5501000PS HIGH
+ 5700000PS HIGH 5701000PS LOW
+ 5900000PS LOW 5901000PS HIGH
+ 6100000PS HIGH 6101000PS LOW
+ 6300000PS LOW 6301000PS HIGH
+ 6500000PS HIGH 6501000PS LOW
+ 6700000PS LOW 6701000PS HIGH
+ 6900000PS HIGH 6901000PS LOW
+ 7100000PS LOW 7101000PS HIGH
+ 7300000PS HIGH 7301000PS LOW
+ 7500000PS LOW 7501000PS HIGH
+ 7700000PS HIGH 7701000PS LOW
+ 7900000PS LOW 7901000PS HIGH
+ 8100000PS HIGH 8101000PS LOW
+ 8300000PS LOW 8301000PS HIGH
+ 8500000PS HIGH 8501000PS LOW
+ 8700000PS LOW 8701000PS HIGH
+ 8900000PS HIGH 8901000PS LOW
+ 9100000PS LOW 9101000PS HIGH
+ 9300000PS HIGH 9301000PS LOW
+ 9500000PS LOW 9501000PS HIGH
+ 9700000PS HIGH 9701000PS LOW
+ 9900000PS LOW 9901000PS HIGH
+ 10100000PS HIGH 10101000PS LOW
+ 10300000PS LOW 10301000PS HIGH
+ 10500000PS HIGH 10501000PS LOW
+ 10700000PS LOW 10701000PS HIGH
+ 10900000PS HIGH 10901000PS LOW
+ 11100000PS LOW 11101000PS HIGH
+ 11300000PS HIGH 11301000PS LOW
+ 11500000PS LOW 11501000PS HIGH
+ 11700000PS HIGH 11701000PS LOW
+ 11900000PS LOW 11901000PS HIGH
+ 12100000PS HIGH 12101000PS LOW
+ 12300000PS LOW 12301000PS HIGH
+ 12500000PS HIGH 12501000PS LOW
+ 12700000PS LOW 12701000PS HIGH
+ 12900000PS HIGH 12901000PS LOW
+ 13100000PS LOW 13101000PS HIGH
+ 13300000PS HIGH 13301000PS LOW
+ 13500000PS LOW 13501000PS HIGH
+ 13700000PS HIGH 13701000PS LOW
+ 13900000PS LOW 13901000PS HIGH
+ 14100000PS HIGH 14101000PS LOW
+ 14300000PS LOW 14301000PS HIGH
+ 14500000PS HIGH 14501000PS LOW
+ 14700000PS LOW 14701000PS HIGH
+ 14900000PS HIGH 14901000PS LOW
+ 15100000PS LOW 15101000PS HIGH
+ 15300000PS HIGH 15301000PS LOW
+ 15500000PS LOW 15501000PS HIGH
+ 15700000PS HIGH 15701000PS LOW
+ 15900000PS LOW 15901000PS HIGH
+ 16100000PS HIGH 16101000PS LOW
+ 16300000PS LOW 16301000PS HIGH
+ 16500000PS HIGH 16501000PS LOW
+ 16700000PS LOW 16701000PS HIGH
+ 16900000PS HIGH 16901000PS LOW
+ 17100000PS LOW 17101000PS HIGH
+ 17300000PS HIGH 17301000PS LOW
+ 17500000PS LOW 17501000PS HIGH
+ 17700000PS HIGH 17701000PS LOW
+ 17900000PS LOW 17901000PS HIGH
+ 18100000PS HIGH 18101000PS LOW
+ 18300000PS LOW 18301000PS HIGH
+ 18500000PS HIGH 18501000PS LOW
+ 18700000PS LOW 18701000PS HIGH
+ 18900000PS HIGH 18901000PS LOW
+ 19100000PS LOW 19101000PS HIGH
+ 19300000PS HIGH 19301000PS LOW
+ 19500000PS LOW 19501000PS HIGH
+ 19700000PS HIGH 19701000PS LOW
+ 19900000PS LOW 19901000PS HIGH
+ 20100000PS HIGH 20101000PS LOW
+ 20300000PS LOW 20301000PS HIGH
+ 20500000PS HIGH 20501000PS LOW
+ 20700000PS LOW 20701000PS HIGH
+ 20900000PS HIGH 20901000PS LOW
+ 21100000PS LOW 21101000PS HIGH
+ 21300000PS HIGH 21301000PS LOW
+ 21500000PS LOW 21501000PS HIGH
+ 21700000PS HIGH 21701000PS LOW
+ 21900000PS LOW 21901000PS HIGH
+ 22100000PS HIGH 22101000PS LOW
+ 22300000PS LOW 22301000PS HIGH
+ 22500000PS HIGH 22501000PS LOW
+ 22700000PS LOW 22701000PS HIGH
+ 22900000PS HIGH 22901000PS LOW
+ 23100000PS LOW 23101000PS HIGH
+ 23300000PS HIGH 23301000PS LOW
+ 23500000PS LOW 23501000PS HIGH
+ 23700000PS HIGH 23701000PS LOW
+ 23900000PS LOW 23901000PS HIGH
+ 24100000PS HIGH 24101000PS LOW
+ 24300000PS LOW 24301000PS HIGH
+ 24500000PS HIGH 24501000PS LOW
+ 24700000PS LOW 24701000PS HIGH
+ 24900000PS HIGH 24901000PS LOW
+ 25100000PS LOW 25101000PS HIGH
+ 25300000PS HIGH 25301000PS LOW
+ 25500000PS LOW 25501000PS HIGH
+ 25700000PS HIGH 25701000PS LOW
+ 25900000PS LOW 25901000PS HIGH
+ 26100000PS HIGH 26101000PS LOW
+ 26300000PS LOW 26301000PS HIGH
+ 26500000PS HIGH 26501000PS LOW
+ 26700000PS LOW 26701000PS HIGH
+ 26900000PS HIGH 26901000PS LOW
+ 27100000PS LOW 27101000PS HIGH
+ 27300000PS HIGH 27301000PS LOW
+ 27500000PS LOW 27501000PS HIGH
+ 27700000PS HIGH 27701000PS LOW
+ 27900000PS LOW 27901000PS HIGH
+ 28100000PS HIGH 28101000PS LOW
+ 28300000PS LOW 28301000PS HIGH
+ 28500000PS HIGH 28501000PS LOW
+ 28700000PS LOW 28701000PS HIGH
+ 28900000PS HIGH 28901000PS LOW
+ 29100000PS LOW 29101000PS HIGH
+ 29300000PS HIGH 29301000PS LOW
+ 29500000PS LOW 29501000PS HIGH
+ 29700000PS HIGH 29701000PS LOW
+ 29900000PS LOW 29901000PS HIGH
+ 30100000PS HIGH 30101000PS LOW
+ 30300000PS LOW 30301000PS HIGH
+ 30500000PS HIGH 30501000PS LOW
+ 30700000PS LOW 30701000PS HIGH
+ 30900000PS HIGH 30901000PS LOW
+ 31100000PS LOW 31101000PS HIGH
+ 31300000PS HIGH 31301000PS LOW
+ 31500000PS LOW 31501000PS HIGH
+ 31700000PS HIGH 31701000PS LOW
+ 31900000PS LOW 31901000PS HIGH
+ 32100000PS HIGH 32101000PS LOW
+ 32300000PS LOW 32301000PS HIGH
+ 32500000PS HIGH 32501000PS LOW
+ 32700000PS LOW 32701000PS HIGH
+ 32900000PS HIGH 32901000PS LOW
+ 33100000PS LOW 33101000PS HIGH
+ 33300000PS HIGH 33301000PS LOW
+ 33500000PS LOW 33501000PS HIGH
+ 33700000PS HIGH 33701000PS LOW
+ 33900000PS LOW 33901000PS HIGH
+ 34100000PS HIGH 34101000PS LOW
+ 34300000PS LOW 34301000PS HIGH
+ 34500000PS HIGH 34501000PS LOW
+ 34700000PS LOW 34701000PS HIGH
+ 34900000PS HIGH 34901000PS LOW
+ 35100000PS LOW 35101000PS HIGH
+ 35300000PS HIGH 35301000PS LOW
+ 35500000PS LOW 35501000PS HIGH
+ 35700000PS HIGH 35701000PS LOW
+ 35900000PS LOW 35901000PS HIGH
+ 36100000PS HIGH 36101000PS LOW
+ 36300000PS LOW 36301000PS HIGH
+ 36500000PS HIGH 36501000PS LOW
+ 36700000PS LOW 36701000PS HIGH
+ 36900000PS HIGH 36901000PS LOW
+ 37100000PS LOW 37101000PS HIGH
+ 37300000PS HIGH 37301000PS LOW
+ 37500000PS LOW 37501000PS HIGH
+ 37700000PS HIGH 37701000PS LOW
+ 37900000PS LOW 37901000PS HIGH
+ 38100000PS HIGH 38101000PS LOW
+ 38300000PS LOW 38301000PS HIGH
+ 38500000PS HIGH 38501000PS LOW
+ 38700000PS LOW 38701000PS HIGH
+ 38900000PS HIGH 38901000PS LOW
+ 39100000PS LOW 39101000PS HIGH
+ 39300000PS HIGH 39301000PS LOW
+ 39500000PS LOW 39501000PS HIGH
+ 39700000PS HIGH 39701000PS LOW
+ 39900000PS LOW 39901000PS HIGH
+ 40100000PS HIGH 40101000PS LOW
+ 40300000PS LOW 40301000PS HIGH
+ 40500000PS HIGH 40501000PS LOW
+ 40700000PS LOW 40701000PS HIGH
+ 40900000PS HIGH 40901000PS LOW
+ 41100000PS LOW 41101000PS HIGH
+ 41300000PS HIGH 41301000PS LOW
+ 41500000PS LOW 41501000PS HIGH
+ 41700000PS HIGH 41701000PS LOW
+ 41900000PS LOW 41901000PS HIGH
+ 42100000PS HIGH 42101000PS LOW
+ 42300000PS LOW 42301000PS HIGH
+ 42500000PS HIGH 42501000PS LOW
+ 42700000PS LOW 42701000PS HIGH
+ 42900000PS HIGH 42901000PS LOW
+ 43100000PS LOW 43101000PS HIGH
+ 43300000PS HIGH 43301000PS LOW
+ 43500000PS LOW 43501000PS HIGH
+ 43700000PS HIGH 43701000PS LOW
+ 43900000PS LOW 43901000PS HIGH
+ 44100000PS HIGH 44101000PS LOW
+ 44300000PS LOW 44301000PS HIGH
+ 44500000PS HIGH 44501000PS LOW
+ 44700000PS LOW 44701000PS HIGH
+ 44900000PS HIGH 44901000PS LOW
+ 45100000PS LOW 45101000PS HIGH
+ 45300000PS HIGH 45301000PS LOW
+ 45500000PS LOW 45501000PS HIGH
+ 45700000PS HIGH 45701000PS LOW
+ 45900000PS LOW 45901000PS HIGH
+ 46100000PS HIGH 46101000PS LOW
+ 46300000PS LOW 46301000PS HIGH
+ 46500000PS HIGH 46501000PS LOW
+ 46700000PS LOW 46701000PS HIGH
+ 46900000PS HIGH 46901000PS LOW
+ 47100000PS LOW 47101000PS HIGH
+ 47300000PS HIGH 47301000PS LOW
+ 47500000PS LOW 47501000PS HIGH
+ 47700000PS HIGH 47701000PS LOW
+ 47900000PS LOW 47901000PS HIGH
+ 48100000PS HIGH 48101000PS LOW
+ 48300000PS LOW 48301000PS HIGH
+ 48500000PS HIGH 48501000PS LOW
+ 48700000PS LOW 48701000PS HIGH
+ 48900000PS HIGH 48901000PS LOW
+ 49100000PS LOW 49101000PS HIGH
+ 49300000PS HIGH 49301000PS LOW
+ 49500000PS LOW 49501000PS HIGH
+ 49700000PS HIGH 49701000PS LOW
+ 49900000PS LOW 49901000PS HIGH
+ 50100000PS HIGH 50101000PS LOW
+ 50300000PS LOW 50301000PS HIGH
+ 50500000PS HIGH 50501000PS LOW
+ 50700000PS LOW 50701000PS HIGH
+ 50900000PS HIGH 50901000PS LOW
+ 51100000PS LOW 51101000PS HIGH
+ 51300000PS HIGH 51301000PS LOW
+ 51500000PS LOW 51501000PS HIGH
+ 51700000PS HIGH 51701000PS LOW
+ 51900000PS LOW 51901000PS HIGH
+ 52100000PS HIGH 52101000PS LOW
+ 52300000PS LOW 52301000PS HIGH
+ 52500000PS HIGH 52501000PS LOW
+ 52700000PS LOW 52701000PS HIGH
+ 52900000PS HIGH 52901000PS LOW
+ 53100000PS LOW 53101000PS HIGH
+ 53300000PS HIGH 53301000PS LOW
+ 53500000PS LOW 53501000PS HIGH
+ 53700000PS HIGH 53701000PS LOW
+ 53900000PS LOW 53901000PS HIGH
+ 54100000PS HIGH 54101000PS LOW
+ 54300000PS LOW 54301000PS HIGH
+ 54500000PS HIGH 54501000PS LOW
+ 54700000PS LOW 54701000PS HIGH
+ 54900000PS HIGH 54901000PS LOW
+ 55100000PS LOW 55101000PS HIGH
+ 55300000PS HIGH 55301000PS LOW
+ 55500000PS LOW 55501000PS HIGH
+ 55700000PS HIGH 55701000PS LOW
+ 55900000PS LOW 55901000PS HIGH
+ 56100000PS HIGH 56101000PS LOW
+ 56300000PS LOW 56301000PS HIGH
+ 56500000PS HIGH 56501000PS LOW
+ 56700000PS LOW 56701000PS HIGH
+ 56900000PS HIGH 56901000PS LOW
+ 57100000PS LOW 57101000PS HIGH
+ 57300000PS HIGH 57301000PS LOW
+ 57500000PS LOW 57501000PS HIGH
+ 57700000PS HIGH 57701000PS LOW
+ 57900000PS LOW 57901000PS HIGH
+ 58100000PS HIGH 58101000PS LOW
+ 58300000PS LOW 58301000PS HIGH
+ 58500000PS HIGH 58501000PS LOW
+ 58700000PS LOW 58701000PS HIGH
+ 58900000PS HIGH 58901000PS LOW
+ 59100000PS LOW 59101000PS HIGH
+ 59300000PS HIGH 59301000PS LOW
+ 59500000PS LOW 59501000PS HIGH
+ 59700000PS HIGH 59701000PS LOW
+ 59900000PS LOW 59901000PS HIGH
+ 60100000PS HIGH 60101000PS LOW
+ 60300000PS LOW 60301000PS HIGH
+ 60500000PS HIGH 60501000PS LOW
+ 60700000PS LOW 60701000PS HIGH
+ 60900000PS HIGH 60901000PS LOW
+ 61100000PS LOW 61101000PS HIGH
+ 61300000PS HIGH 61301000PS LOW
+ 61500000PS LOW 61501000PS HIGH
+ 61700000PS HIGH 61701000PS LOW
+ 61900000PS LOW 61901000PS HIGH
+ 62100000PS HIGH 62101000PS LOW
+ 62300000PS LOW 62301000PS HIGH
+ 62500000PS HIGH 62501000PS LOW
+ 62700000PS LOW 62701000PS HIGH
+ 62900000PS HIGH 62901000PS LOW
+ 63100000PS LOW 63101000PS HIGH
+ 63300000PS HIGH 63301000PS LOW
+ 63500000PS LOW 63501000PS HIGH
+ 63700000PS HIGH 63701000PS LOW
+ 63900000PS LOW 63901000PS HIGH
+ 64100000PS HIGH 64101000PS LOW
+ 64300000PS LOW 64301000PS HIGH
+ 64500000PS HIGH 64501000PS LOW
+ 64700000PS LOW 64701000PS HIGH
+ 64900000PS HIGH 64901000PS LOW
+ 65100000PS LOW 65101000PS HIGH
+ 65300000PS HIGH 65301000PS LOW
+ 65500000PS LOW 65501000PS HIGH
+ 65700000PS HIGH 65701000PS LOW
+ 65900000PS LOW 65901000PS HIGH
+ 66100000PS HIGH 66101000PS LOW
+ 66300000PS LOW 66301000PS HIGH
+ 66500000PS HIGH 66501000PS LOW
+ 66700000PS LOW 66701000PS HIGH
+ 66900000PS HIGH 66901000PS LOW
+ 67100000PS LOW 67101000PS HIGH
+ 67300000PS HIGH 67301000PS LOW
+ 67500000PS LOW 67501000PS HIGH
+ 67700000PS HIGH 67701000PS LOW
+ 67900000PS LOW 67901000PS HIGH
+ 68100000PS HIGH 68101000PS LOW
+ 68300000PS LOW 68301000PS HIGH
+ 68500000PS HIGH 68501000PS LOW
+ 68700000PS LOW 68701000PS HIGH
+ 68900000PS HIGH 68901000PS LOW
+ 69100000PS LOW 69101000PS HIGH
+ 69300000PS HIGH 69301000PS LOW
+ 69500000PS LOW 69501000PS HIGH
+ 69700000PS HIGH 69701000PS LOW
+ 69900000PS LOW 69901000PS HIGH
+ 70100000PS HIGH 70101000PS LOW
+ 70300000PS LOW 70301000PS HIGH
+ 70500000PS HIGH 70501000PS LOW
+ 70700000PS LOW 70701000PS HIGH
+ 70900000PS HIGH 70901000PS LOW
+ 71100000PS LOW 71101000PS HIGH
+ 71300000PS HIGH 71301000PS LOW
+ 71500000PS LOW 71501000PS HIGH
+ 71700000PS HIGH 71701000PS LOW
+ 71900000PS LOW 71901000PS HIGH
+ 72100000PS HIGH 72101000PS LOW
+ 72300000PS LOW 72301000PS HIGH
+ 72500000PS HIGH 72501000PS LOW
+ 72700000PS LOW 72701000PS HIGH
+ 72900000PS HIGH 72901000PS LOW
+ 73100000PS LOW 73101000PS HIGH
+ 73300000PS HIGH 73301000PS LOW
+ 73500000PS LOW 73501000PS HIGH
+ 73700000PS HIGH 73701000PS LOW
+ 73900000PS LOW 73901000PS HIGH
+ 74100000PS HIGH 74101000PS LOW
+ 74300000PS LOW 74301000PS HIGH
+ 74500000PS HIGH 74501000PS LOW
+ 74700000PS LOW 74701000PS HIGH
+ 74900000PS HIGH 74901000PS LOW
+ 75100000PS LOW 75101000PS HIGH
+ 75300000PS HIGH 75301000PS LOW
+ 75500000PS LOW 75501000PS HIGH
+ 75700000PS HIGH 75701000PS LOW
+ 75900000PS LOW 75901000PS HIGH
+ 76100000PS HIGH 76101000PS LOW
+ 76300000PS LOW 76301000PS HIGH
+ 76500000PS HIGH 76501000PS LOW
+ 76700000PS LOW 76701000PS HIGH
+ 76900000PS HIGH 76901000PS LOW
+ 77100000PS LOW 77101000PS HIGH
+ 77300000PS HIGH 77301000PS LOW
+ 77500000PS LOW 77501000PS HIGH
+ 77700000PS HIGH 77701000PS LOW
+ 77900000PS LOW 77901000PS HIGH
+ 78100000PS HIGH 78101000PS LOW
+ 78300000PS LOW 78301000PS HIGH
+ 78500000PS HIGH 78501000PS LOW
+ 78700000PS LOW 78701000PS HIGH
+ 78900000PS HIGH 78901000PS LOW
+ 79100000PS LOW 79101000PS HIGH
+ 79300000PS HIGH 79301000PS LOW
+ 79500000PS LOW 79501000PS HIGH
+ 79700000PS HIGH 79701000PS LOW
+ 79900000PS LOW 79901000PS HIGH
+ 80100000PS HIGH 80101000PS LOW
+ 80300000PS LOW 80301000PS HIGH
+ 80500000PS HIGH 80501000PS LOW
+ 80700000PS LOW 80701000PS HIGH
+ 80900000PS HIGH 80901000PS LOW
+ 81100000PS LOW 81101000PS HIGH
+ 81300000PS HIGH 81301000PS LOW
+ 81500000PS LOW 81501000PS HIGH
+ 81700000PS HIGH 81701000PS LOW
+ 81900000PS LOW 81901000PS HIGH
+ 82100000PS HIGH 82101000PS LOW
+ 82300000PS LOW 82301000PS HIGH
+ 82500000PS HIGH 82501000PS LOW
+ 82700000PS LOW 82701000PS HIGH
+ 82900000PS HIGH 82901000PS LOW
+ 83100000PS LOW 83101000PS HIGH
+ 83300000PS HIGH 83301000PS LOW
+ 83500000PS LOW 83501000PS HIGH
+ 83700000PS HIGH 83701000PS LOW
+ 83900000PS LOW 83901000PS HIGH
+ 84100000PS HIGH 84101000PS LOW
+ 84300000PS LOW 84301000PS HIGH
+ 84500000PS HIGH 84501000PS LOW
+ 84700000PS LOW 84701000PS HIGH
+ 84900000PS HIGH 84901000PS LOW
+ 85100000PS LOW 85101000PS HIGH
+ 85300000PS HIGH 85301000PS LOW
+ 85500000PS LOW 85501000PS HIGH
+ 85700000PS HIGH 85701000PS LOW
+ 85900000PS LOW 85901000PS HIGH
+ 86100000PS HIGH 86101000PS LOW
+ 86300000PS LOW 86301000PS HIGH
+ 86500000PS HIGH 86501000PS LOW
+ 86700000PS LOW 86701000PS HIGH
+ 86900000PS HIGH 86901000PS LOW
+ 87100000PS LOW 87101000PS HIGH
+ 87300000PS HIGH 87301000PS LOW
+ 87500000PS LOW 87501000PS HIGH
+ 87700000PS HIGH 87701000PS LOW
+ 87900000PS LOW 87901000PS HIGH
+ 88100000PS HIGH 88101000PS LOW
+ 88300000PS LOW 88301000PS HIGH
+ 88500000PS HIGH 88501000PS LOW
+ 88700000PS LOW 88701000PS HIGH
+ 88900000PS HIGH 88901000PS LOW
+ 89100000PS LOW 89101000PS HIGH
+ 89300000PS HIGH 89301000PS LOW
+ 89500000PS LOW 89501000PS HIGH
+ 89700000PS HIGH 89701000PS LOW
+ 89900000PS LOW 89901000PS HIGH
+ 90100000PS HIGH 90101000PS LOW
+ 90300000PS LOW 90301000PS HIGH
+ 90500000PS HIGH 90501000PS LOW
+ 90700000PS LOW 90701000PS HIGH
+ 90900000PS HIGH 90901000PS LOW
+ 91100000PS LOW 91101000PS HIGH
+ 91300000PS HIGH 91301000PS LOW
+ 91500000PS LOW 91501000PS HIGH
+ 91700000PS HIGH 91701000PS LOW
+ 91900000PS LOW 91901000PS HIGH
+ 92100000PS HIGH 92101000PS LOW
+ 92300000PS LOW 92301000PS HIGH
+ 92500000PS HIGH 92501000PS LOW
+ 92700000PS LOW 92701000PS HIGH
+ 92900000PS HIGH 92901000PS LOW
+ 93100000PS LOW 93101000PS HIGH
+ 93300000PS HIGH 93301000PS LOW
+ 93500000PS LOW 93501000PS HIGH
+ 93700000PS HIGH 93701000PS LOW
+ 93900000PS LOW 93901000PS HIGH
+ 94100000PS HIGH 94101000PS LOW
+ 94300000PS LOW 94301000PS HIGH
+ 94500000PS HIGH 94501000PS LOW
+ 94700000PS LOW 94701000PS HIGH
+ 94900000PS HIGH 94901000PS LOW
+ 95100000PS LOW 95101000PS HIGH
+ 95300000PS HIGH 95301000PS LOW
+ 95500000PS LOW 95501000PS HIGH
+ 95700000PS HIGH 95701000PS LOW
+ 95900000PS LOW 95901000PS HIGH
+ 96100000PS HIGH 96101000PS LOW
+ 96300000PS LOW 96301000PS HIGH
+ 96500000PS HIGH 96501000PS LOW
+ 96700000PS LOW 96701000PS HIGH
+ 96900000PS HIGH 96901000PS LOW
+ 97100000PS LOW 97101000PS HIGH
+ 97300000PS HIGH 97301000PS LOW
+ 97500000PS LOW 97501000PS HIGH
+ 97700000PS HIGH 97701000PS LOW
+ 97900000PS LOW 97901000PS HIGH
+ 98100000PS HIGH 98101000PS LOW
+ 98300000PS LOW 98301000PS HIGH
+ 98500000PS HIGH 98501000PS LOW
+ 98700000PS LOW 98701000PS HIGH
+ 98900000PS HIGH 98901000PS LOW
+ 99100000PS LOW 99101000PS HIGH
+ 99300000PS HIGH 99301000PS LOW
+ 99500000PS LOW 99501000PS HIGH
+ 99700000PS HIGH 99701000PS LOW
+ 99900000PS LOW 99901000PS HIGH
+ 100100000PS HIGH 100101000PS LOW
+ 100300000PS LOW 100301000PS HIGH
+ 100500000PS HIGH 100501000PS LOW
+ 100700000PS LOW 100701000PS HIGH
+ 100900000PS HIGH 100901000PS LOW
+ 101100000PS LOW 101101000PS HIGH
+ 101300000PS HIGH 101301000PS LOW
+ 101500000PS LOW 101501000PS HIGH
+ 101700000PS HIGH 101701000PS LOW
+ 101900000PS LOW 101901000PS HIGH
+ 102100000PS HIGH 102101000PS LOW
+ 102300000PS LOW 102301000PS HIGH
+ 102500000PS HIGH 102501000PS LOW
+ 102700000PS LOW 102701000PS HIGH
+ 102900000PS HIGH 102901000PS LOW
+ 103100000PS LOW 103101000PS HIGH
+ 103300000PS HIGH 103301000PS LOW
+ 103500000PS LOW 103501000PS HIGH
+ 103700000PS HIGH 103701000PS LOW
+ 103900000PS LOW 103901000PS HIGH
+ 104100000PS HIGH 104101000PS LOW
+ 104300000PS LOW 104301000PS HIGH
+ 104500000PS HIGH 104501000PS LOW
+ 104700000PS LOW 104701000PS HIGH
+ 104900000PS HIGH 104901000PS LOW
+ 105100000PS LOW 105101000PS HIGH
+ 105300000PS HIGH 105301000PS LOW
+ 105500000PS LOW 105501000PS HIGH
+ 105700000PS HIGH 105701000PS LOW
+ 105900000PS LOW 105901000PS HIGH
+ 106100000PS HIGH 106101000PS LOW
+ 106300000PS LOW 106301000PS HIGH
+ 106500000PS HIGH 106501000PS LOW
+ 106700000PS LOW 106701000PS HIGH
+ 106900000PS HIGH 106901000PS LOW
+ 107100000PS LOW 107101000PS HIGH
+ 107300000PS HIGH 107301000PS LOW
+ 107500000PS LOW 107501000PS HIGH
+ 107700000PS HIGH 107701000PS LOW
+ 107900000PS LOW 107901000PS HIGH
+ 108100000PS HIGH 108101000PS LOW
+ 108300000PS LOW 108301000PS HIGH
+  )

vinput26 cin 0 PWL (
+ 0PS LOW 1000PS LOW
+ 49700000PS LOW 49701000PS HIGH
+ 68900000PS HIGH 68901000PS LOW
+ 95700000PS LOW 95701000PS HIGH
+  )

vinput27 ram_i_down 0 PWL (
+ 0PS LOW 1000PS LOW
+ 9700000PS LOW 9701000PS HIGH
+ 10100000PS HIGH 10101000PS LOW
+ 10500000PS LOW 10501000PS HIGH
+ 10900000PS HIGH 10901000PS LOW
+ 11300000PS LOW 11301000PS HIGH
+ 11700000PS HIGH 11701000PS LOW
+ 12100000PS LOW 12101000PS HIGH
+ 12500000PS HIGH 12501000PS LOW
+  )

vinput29 ram_i_up 0 PWL (
+ 0PS LOW 1000PS LOW
+ 1300000PS LOW 1301000PS HIGH
+ 1700000PS HIGH 1701000PS LOW
+ 2100000PS LOW 2101000PS HIGH
+ 2500000PS HIGH 2501000PS LOW
+ 2900000PS LOW 2901000PS HIGH
+ 3300000PS HIGH 3301000PS LOW
+ 3700000PS LOW 3701000PS HIGH
+ 4100000PS HIGH 4101000PS LOW
+ 4500000PS LOW 4501000PS HIGH
+ 8100000PS HIGH 8101000PS LOW
+  )

vinput31 acc_i_down 0 PWL (
+ 0PS LOW 1000PS LOW
+ 9700000PS LOW 9701000PS HIGH
+ 10100000PS HIGH 10101000PS LOW
+ 10500000PS LOW 10501000PS HIGH
+ 10900000PS HIGH 10901000PS LOW
+ 11300000PS LOW 11301000PS HIGH
+ 11700000PS HIGH 11701000PS LOW
+ 12100000PS LOW 12101000PS HIGH
+ 12500000PS HIGH 12501000PS LOW
+  )

vinput33 acc_i_up 0 PWL (
+ 0PS LOW 1000PS LOW
+ 1300000PS LOW 1301000PS HIGH
+ 1700000PS HIGH 1701000PS LOW
+ 2100000PS LOW 2101000PS HIGH
+ 2500000PS HIGH 2501000PS LOW
+ 2900000PS LOW 2901000PS HIGH
+ 3300000PS HIGH 3301000PS LOW
+ 3700000PS LOW 3701000PS HIGH
+ 4100000PS HIGH 4101000PS LOW
+ 4500000PS LOW 4501000PS HIGH
+ 8100000PS HIGH 8101000PS LOW
+  )
